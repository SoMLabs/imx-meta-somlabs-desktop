require recipes-kernel/linux/linux-imx-somlabs-desktop-src.inc
